# Keil uVision project F4_proj1.uvprojx, settings and files
target F4_proj1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F4_proj1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT
  c include: ../Inc;           ../Drivers/STM32F4xx_HAL_Driver/Inc;           ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;           ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;           ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;           ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;           ../Middlewares/Third_Party/FatFs/src;           ../Middlewares/Third_Party/FreeRTOS/Source/include;           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;           ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/User
    ../Src/: usbd_desc.c usb_device.c stm32f4xx_hal_msp.c usbd_cdc_if.c sd_diskio.c usbd_conf.c main.c bsp_driver_sd.c freertos.c stm32f4xx_it.c fatfs.c stm32f4xx_hal_timebase_TIM.c c2enc.c codec2.c quantise.c sine.c newamp2.c codebook.c codebookd.c codebookdt.c codebookge.c codebookjvm.c codebooknewamp1_energy.c codebookres.c codec2_fft.c codec2_fifo.c dump.c filter.c golay23.c gp_interleaver.c HRA_112_112.c HRAb_396_504.c interp.c linreg.c lpc.c lsp.c mbest.c nlp.c pack.c phase.c phi0.c postfilter.c codebooknewamp2_energy.c codebooknewamp2.c codebookmel.c codebooklspmelvq.c newamp1.c W25QXX.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sd.c stm32f4xx_hal_rng.c stm32f4xx_hal_pcd.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c croutine.c list.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
